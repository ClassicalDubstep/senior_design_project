# Keil uVision project senior design project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L011D4Px STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: senior design project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L011D4Px/STCubeGenerated/Src/: main.c stm32l0xx_it.c
    ./RTE/Device/STM32L011D4Px/STCubeGenerated/Inc/: stm32l0xx_it.h
software components: CMSIS:CORE 5.2.0, Device:STM32Cube HAL 1.10.0
